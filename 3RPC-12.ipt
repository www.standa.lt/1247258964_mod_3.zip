# Autodesk Inventor part: 3RPC-12
## iProperties
Created: 2006-11
Part Number: 3RPC-12
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
